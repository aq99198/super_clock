### uVision2 Project, (C) Keil Software
### Do not modify !

Target (Target 1), 0x0000 // Tools: 'MCS-51'

Group (os)
Group (user)
Group (Target CPU)
Group (drivers)

File 1,1,<..\small_rtos\OS\OS_CORE.C><OS_CORE.C> 0x0 
File 1,1,<..\small_rtos\OS\OS_MEM.C><OS_MEM.C> 0x0 
File 1,1,<..\small_rtos\OS\OS_Q.C><OS_Q.C> 0x0 
File 1,1,<..\small_rtos\OS\OS_SEM.C><OS_SEM.C> 0x0 
File 2,1,<.\main.c><main.c> 0x0 
File 3,2,<..\small_rtos\KEILC51\OS_CPU_A.ASM><OS_CPU_A.ASM> 0x0 
File 3,1,<..\small_rtos\KEILC51\OS_CPU_C.C><OS_CPU_C.C> 0x0 
File 4,1,<..\small_rtos\drivers\beep.c><beep.c> 0x0 
File 4,1,<..\small_rtos\drivers\core.c><core.c> 0x0 
File 4,1,<..\small_rtos\drivers\DS18B20.c><DS18B20.c> 0x0 
File 4,1,<..\small_rtos\drivers\DS1302.c><DS1302.c> 0x0 
File 4,1,<..\small_rtos\drivers\leds.c><leds.c> 0x0 
File 4,1,<..\small_rtos\drivers\null.c><null.c> 0x0 
File 4,1,<..\small_rtos\drivers\uart.c><uart.c> 0x0 
File 4,1,<..\small_rtos\drivers\keys.c><keys.c> 0x0 


Options 1,0,0  // Target 'Target 1'
 Device (89C52)
 Vendor (Atmel)
 Cpu (IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000))
 FlashUt ((null))
 StupF ((null))
 FlashDR ((null))
 Rgf (AT89X52.H)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg (ÿAtmel\)
 OrgReg (ÿAtmel\)
 TgStat=0
 OutDir (E:\TEMP\)
 OutName (test)
 GenApp=1
 GenLib=0
 GenHex=1
 Debug=1
 Browse=1
 LstDir (E:\temp\)
 HexSel=0
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 SVCSID <>
 MODEL5=0
 RTOS5=0
 ROMSZ5=2
 DHOLD5=0
 XHOLD5=0
 T51FL=80
 CBANKS5=0
 XBANKS5=0
 RCB51 { 0,0,0,0,0,255,255,0,0 }
 RXB51 { 0,0,0,0,0,0,0,0,0 }
 OCM51 { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCR51 { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IRO51 { 1,0,0,0,0,0,32,0,0 }
 IRA51 { 0,0,0,0,0,0,1,0,0 }
 XRA51 { 0,0,0,0,0,0,0,0,0 }
 XRA512 { 0,0,0,0,0,0,0,0,0 }
 C51FL=21613840
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 (E:\program\super_clock\software\app\)
 AX51FL=4
 AX51MSC ()
 AX51SET ()
 AX51RST ()
 INCA5 ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 BankNo=65535
 LX51FL=292
 LX51OVL ()
 LX51MSC ()
 LX51DWN ()
 LX51LFI ()
 LX51ASN ()
 LX51RES ()
 LX51CCL ()
 LX51UCL ()
 LX51CSC ()
 LX51UCS ()
 LX51COB ()
 LX51XDB ()
 LX51PDB ()
 LX51BIB ()
 LX51DAB ()
 LX51IDB ()
 LX51PRC ()
 LX51STK ()
 LX51COS ()
 LX51XDS ()
 LX51BIS ()
 LX51DAS ()
 LX51IDS ()
  OPTDL (S8051.DLL)()(DP51.DLL)(-p52)(S8051.DLL)()(TP51.DLL)(-p52)
  OPTDBG 509,-1,()()()()()()()()()() ()()()()
 FLASH1 { 1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 FLASH2 ()
 FLASH3 ("" (null))
EndOpt

Options 1,2,0  // Group 'user'
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=2
 AlwaysBuild=2
 GenAsm=2
 AsmAsm=2
 PublicsOnly=2
 StopCode=11
 CustArgs ()
 LibMods ()
 BankNo=65535
 C51FL=177119914
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 (..\small_rtos\drivers\;..\\small_rtos\OS\)
 AX51FL=170
 AX51MSC ()
 AX51SET ()
 AX51RST ()
 INCA5 ()
EndOpt

